## drivers/sensor/sfa30/Kconfig
```kconfig
config SFA30
	bool "Sensirion SFA30"
	depends on I2C
	help
	  Enable driver for SFA30 sensor.
```
